# Keil uVision project AEV_Board_STM32F4_FMS.uvprojx, settings and files
target AEV_Board_STM32F4_FMS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: AEV_Board_STM32F4_FMS
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000
  c include: ..\CMSIS;..\STM32F4xx_StdPeriph_Driver\inc;..\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../Src/: main.c gps_handler.c sign.c delay.c gps_config.c access_GUI.c LTE_handler.c
  group CMSIS
    ../CMSIS/: stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h
  group STM32F4xx_StdPeriph_Driver
    ../STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_flash.c
software components: CMSIS:CORE 5.5.0, Device:Startup 2.6.3
